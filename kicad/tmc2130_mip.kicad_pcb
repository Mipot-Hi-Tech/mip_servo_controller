# Repository Mipot-Hi-Tech/mip_servo_controller

File README.md:

<!-- For .md file development refers to https://docs.github.com/en -->
# [MIP](https://mipot.com/en/products/?cat=110) Series Design and Firmware Example for Dual Core

## Wireless Triple Stepper/Servo Controller 

Designed to remote control up to three axis mechatronic system.
Build with [MIPOT](https://www.mipot.com) [32001506DEU](https://mipot.com/en/products/mip-series/dual-core/32001506deu/).

## Compatibility

 - [32001506AEU](https://mipot.com/en/products/mip-series/dual-core/32001506aeu/) - 868 MHz Wireless M-Bus
 - [32001506BEU](https://mipot.com/en/products/mip-series/dual-core/32001506beu/) - 868 MHz LoRaWAN
 - [32001506CEU](https://mipot.com/en/products/mip-series/dual-core/32001506ceu/) - 868 MHz LoRa Mipot
 - [32001506DEU](https://mipot.com/en/products/mip-series/dual-core/32001506deu/) - 868 MHz LoRa Modem
 - [32001506BUS](https://mipot.com/en/products/mip-series/dual-core/32001506bus/) - 915 MHz LoRaWAN

> [!TIP]
> MIP C library is avaliable in the [Official Repository](https://github.com/Mipot-Hi-Tech/mip).

## Board Overview

## Top Side of the board

## Bottom Side of The board

## Board with 4 layers for EMI Compliance

## Build with Kicad

## Mode of Operation

## Closeup

## SPI commonucation between microcontroller and TMC2130 Drivers

## Embedded shell for Hardware Debug

## Folder content and description

- **firmware:** Source code of the microcontroller written in C.
	- **Core:** The application files, system and peripheral configuration.
	- **freertos:** The Freertos kernel. *Keep read only*.
	- **freertos_cli:** The Freertos command line interface source code. *Keep read only*.
	- **wl-lib:** STM32 HAL and LL Drivers. *Keep read only*.
	- **trinamic_lib:** Driver of TMC2130 stepper controller.
	- **miplib** Driver of MIP series modules.
- **img:** Development and test images of the project.
- **kicad:** hardware design files.Source files of schematic and PCB.
	- **lib:** Symbols and footprints of the components.
- **production:** Production files. Gerbers, BOM and Stencil.
- **doc:** Schematic of the board. PDF format.

## Firmware Overview

Based on [Freertos](https://www.freertos.org).

## Software needed for development

- [STM32CubeIDE](https://www.st.com/en/development-tools/stm32cubeide.html) **1.17.0**
- [KICAD](https://www.kicad.org/) **8.0.5**
- [GIT](https://git-scm.com/) **2.46.1.windows.1**
- [Tera Term](https://teratermproject.github.io/index-en.html) **5.3 x86**

## Tools needed for development

- Programmer [STLINK](https://www.st.com/en/development-tools/st-link-v2.html)
- Serial Cable [TTL-232R-3V3](https://ftdichip.com/products/ttl-232r-3v3/)

## License

Shown in the LICENSE.md file

## Important Information

> [!CAUTION]
> Manual soldering of SMD components requires high level of manual skills.

> [!CAUTION]
> This project is a hardware/firmware solution example on MIP Series.
> The main goal is to give a starting point on MIP Series Development.
> There are better open source solutions to control steppers motors.

> [!CAUTION]
> This project is provided "AS IS" with no warranties.

## KiCad design kicad/tmc2130_mip.kicad_pcb

Parts:
AE1: Antenna; Texas_SWRA416_868MHz_915MHz
C1: 4u7; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; Voltage 16 V; Mouser 81-GRM21BR71C475KE1L
C2, C3, C71, C72: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 100 V; Mouser 187-CL10B104KC8NNNC
C4: 1p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; not fitted
C62: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; not fitted
FID1, FID2: Fiducial; Fiducial_2.0mm_Mask4.0mm
H1, H2, H3, H4: MountingHole_Pad; MountingHole_4.3mm_M4_ISO7380_Pad_TopBottom
J1: Conn_01x06_Pin; PinSocket_1x06_P2.54mm_Vertical
J2: Conn_01x06_Pin; PinHeader_1x06_P2.54mm_Vertical
J4: Conn_Coaxial; U.FL_Molex_MCRF_73412-0110_Vertical; Mouser 538-73412-0110; not fitted
JP1: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
M1: 32001505/6CEU; 32001514_R2
R1, R82: 0R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
R2, R3, R4, R5, R6, R8, R9, R10: 22R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser 603-AC0603JR-0722RL
R11, R12: 0R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser 603-RC0603FR-100RL
R80, R81: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
R87: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser 603-RC0603JR-0710KL
U5: ISM330DLCTR; PQFN50P250X300X86-14N; PARTREV 2; not fitted
U9: MCP6001-OT; SOT-23-5; Mouser 579-MCP6001T-E/OT

Connections:
+3V3: C1.2, C2.2, C3.2, C62.2, C72.2, M1.A9 (VDD), M1.B8 (VDDA), M1.B9 (VDD), M1.C7 (VREF+), M1.D7 (VBAT), R5.2, R80.1, R81.1, R82.1, U5.5 (VDDIO), U5.8 (VDD), U9.5 (V+); also elsewhere on the board
/CPU/AIN_REF: U9.1, U9.4 (-); also elsewhere on the board
/CPU/AIN_REF_MIP: M1.D6 (DAC_OUT1), R87.1
/CPU/ANT_OUT: M1.F1 (ANT), R1.2, R11.2
/CPU/CLK: M1.G9 (SPI2_SCK); also elsewhere on the board
/CPU/DRV0_DIAGNOSTIC: M1.E6 (COMP2_INM); also elsewhere on the board
/CPU/DRV0_DIR: M1.A1 (SPI1_MISO); also elsewhere on the board
/CPU/DRV0_EN: M1.A2 (SPI1_CLK); also elsewhere on the board
/CPU/DRV0_STEP: M1.D2 (TIM2_CH3); also elsewhere on the board
/CPU/DRV1_DIAGNOSTIC: M1.B4 (USART2_RX); also elsewhere on the board
/CPU/DRV1_DIR: M1.D5 (ADC_IN1); also elsewhere on the board
/CPU/DRV1_EN: M1.C6 (COMP1_INP); also elsewhere on the board
/CPU/DRV1_STEP: M1.D3 (TIM2_CH4); also elsewhere on the board
/CPU/DRV2_DIAGNOSTIC: M1.B7 (COMP2_INP); also elsewhere on the board
/CPU/DRV2_DIR: M1.A6 (SPI1_MOSI); also elsewhere on the board
/CPU/DRV2_EN: M1.C4 (TIM2_CH2); also elsewhere on the board
/CPU/DRV2_STEP: M1.C5 (TIM2_CH1); also elsewhere on the board
/CPU/MISO: M1.D9 (SPI2_MISO); also elsewhere on the board
/CPU/MOD_NWAKE: M1.B1 (GPIO0_NWAKE), R4.2; also elsewhere on the board
/CPU/MOD_RX: M1.A5 (LPUART1_RX), R2.2; also elsewhere on the board
/CPU/MOD_TX: M1.A4 (LPUART1_TX), R3.2; also elsewhere on the board
/CPU/MOSI: M1.E9 (SPI2_MOSI); also elsewhere on the board
/CPU/VEXT_SENSE: M1.D8 (ADC_IN0); also elsewhere on the board
/CPU/~DRV0_SPI_SS: M1.A3 (SPI1_NSS); also elsewhere on the board
/CPU/~DRV1_SPI_SS: M1.F9 (SPI2_NSS); also elsewhere on the board
/CPU/~DRV2_SPI_SS: M1.E7 (ADC_IN8); also elsewhere on the board
GND: C1.1, C2.1, C3.1, C4.1, C62.1, C71.1, C72.1, H1.1, H2.1, H3.1, H4.1, J1.1, J2.3, J4.2 (Ext), JP1.1 (A), M1.C9 (GND), M1.D1 (GND), M1.E1 (GND), M1.E2 (GND), M1.F2 (GND), M1.G1 (GND), M1.G2 (GND), M1.G3 (GND), M1.GD (GND_EVK), U5.2 (SDX), U5.3 (SCX), U5.6 (GND), U5.7 (GND), U9.2 (V-); also elsewhere on the board
I2C_SCL: M1.A7 (I2C1_SCL), R80.2, U5.13 (SCL)
I2C_SDA: M1.A8 (I2C1_SDA), R81.2, U5.14 (SDA)
unnamed: AE1.1 (A), R12.1
unnamed: C4.2, R11.1, R12.2
unnamed: J1.4, R2.1
unnamed: J1.5, R3.1
unnamed: J1.6, R4.1
unnamed: J2.1, R5.1
unnamed: J2.2, R6.1
unnamed: J2.4, R8.1
unnamed: J2.5, R9.1
unnamed: J2.6, R10.1
unnamed: J4.1 (In), R1.1
unnamed: JP1.2 (B), M1.G5 (T_NRST), R9.2
unnamed: M1.G7 (T_SWCLK), R6.2
unnamed: M1.G6 (T_SWDIO), R8.2
unnamed: M1.G8 (T_SWO), R10.2
unnamed: R82.2, U5.12 (CS)
unnamed: C71.2, R87.2, U9.3 (+)

Notes on the sheet:
MEMS & SENSORS
MICROCONTROLLER + RADIO
MOUNTING HOLES
ANALOG REFERENCE FOR STEPPER DRIVERS
868 MHZ ANTENNA

Parts:
C5: 22n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V; Mouser 810-C1608X7R1H223K
C6, C7, C19, C64, C73: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 100V; Mouser 187-CL10B104KC8NNNC
C8: 4u7; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Voltage 100 V; Mouser 81-GRM31CZ72A475K11L
C9: 150u; CP_Radial_D10.0mm_P5.00mm; Voltage 63 V; Mouser 667-EEU-FR1J151
C10: 150u; CP_Radial_D10.0mm_P5.00mm; Voltage 63 V; Mouser 667-EEU-FR1J151; not fitted
C11, C12, C13, C14: 470p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; not fitted
C15, C16: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 100 V; Mouser 187-CL10B104KC8NNNC; not fitted
C17: 4u7; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; Voltage 16 V; Mouser 81-GRM21BR71C475KE1L
C18: 470n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 25 V; Mouser 187-CL10B474KA8NNNC
J3: PHOENIX CONTACT 1755752; PHOENIX_1755752; Mouser 651-1755752
J11: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
J15: PHOENIX_MVSTBR 2,5 4-ST-5,08; Mouser 651-1792265
MOT1: TMC2130-LA; TMC_QFN36_0.5_5.0X6.0; Mouser 700-TMC2130LA
R13, R18, R19, R23, R25: 0R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser 603-RC0603FR-100RL
R14, R15, R16, R17, R20, R26, R27: 22R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser 603-AC0603JR-0722RL
R21, R22: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser 603-RC0603JR-0710KL
R24, R77: 0R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
R28, R29: 0R22; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder; Mouser 603-RL1206FR070R22L
R30: 2R2; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser 603-RC0603JR-072R2L
TP1, TP2: TestPoint; TestPoint_Pad_D1.0mm

Connections:
+3V3: C19.2, MOT1.8 (VCC_IO), R21.1, R22.1; also elsewhere on the board
+6V: C64.2, MOT1.30 (VSA); also elsewhere on the board
/CPU/AIN_REF: R25.1; also elsewhere on the board
/CPU/CLK: R16.1; also elsewhere on the board
/CPU/DRV0_DIAGNOSTIC: MOT1.21 (DIAG1_SWP), R22.2; also elsewhere on the board
/CPU/DRV0_DIR: R27.1; also elsewhere on the board
/CPU/DRV0_EN: R20.1; also elsewhere on the board
/CPU/DRV0_STEP: R26.1; also elsewhere on the board
/CPU/MISO: R14.1; also elsewhere on the board
/CPU/MOSI: R15.1; also elsewhere on the board
/CPU/~DRV0_SPI_SS: R17.1; also elsewhere on the board
GND: C7.1, C8.1, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.1, C16.1, C17.1, C18.1, C19.1, C64.1, C73.1, J11.3, MOT1.12 (GNDP_1), MOT1.24 (GNDA), MOT1.35 (GNDP_2), MOT1.36 (TST_MODE), MOT1.37 (GND_PAD), R13.1, R18.1, R19.1, R23.1, R24.1, R28.1, R29.1; also elsewhere on the board
unnamed: C11.1, J3.1, MOT1.34 (OA1)
unnamed: C12.1, J3.2, MOT1.32 (OA2)
unnamed: C13.1, J3.3, MOT1.13 (OB1)
unnamed: C14.1, J3.4, MOT1.15 (OB2)
unnamed: J11.1, MOT1.6 (STEP_REFL), R26.2
unnamed: J11.2, R77.1
unnamed: C17.2, MOT1.25 (5V_OUT), R30.2
unnamed: MOT1.23 (AIN_IREF), R25.2
unnamed: C16.2, MOT1.33 (BRA), R29.2, TP2.1
unnamed: C15.2, MOT1.14 (BRB), R28.2, TP1.1
unnamed: MOT1.1 (CLK), R13.2
unnamed: C5.1, MOT1.28 (CPI)
unnamed: C5.2, MOT1.27 (CPO)
unnamed: MOT1.18 (DCEN_ENCB_CFG4), R18.2
unnamed: MOT1.19 (DCIN_ENCA_CFG5), R19.2
unnamed: MOT1.17 (DCO_ENCN), R23.2
unnamed: MOT1.20 (DIAG0_SWN), R21.2
unnamed: MOT1.7 (DIR_REFR), R27.2
unnamed: MOT1.22 (DRV_~EN_CFG6), R20.2
unnamed: MOT1.3 (SCK_CFG2), R16.2
unnamed: MOT1.4 (SDI_CFG1), R15.2
unnamed: MOT1.5 (SDO_CFG0), R14.2
unnamed: MOT1.10 (SPI_MODE), R24.2
unnamed: C18.2, MOT1.26 (VCC), R30.1
unnamed: C6.1, MOT1.29 (VCP)
unnamed: MOT1.2 (~CS_CFG3), R17.2
VEXT: C6.2, C7.2, C8.2, C9.1, C10.1, C73.2, MOT1.16 (VS_1), MOT1.31 (VS_2), R77.2; also elsewhere on the board

Parts of its further copies:
C20, C35: 22n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50V; Mouser 810-C1608X7R1H223K
C21, C22, C34, C36, C37, C49, C68, C69, C74, C75: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 100V; Mouser 187-CL10B104KC8NNNC
C23, C38: 4u7; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Voltage 100 V; Mouser 81-GRM31CZ72A475K11L
C24, C39: 150u; CP_Radial_D10.0mm_P5.00mm; Voltage 63 V; Mouser 667-EEU-FR1J151
C25, C40: 150u; CP_Radial_D10.0mm_P5.00mm; Voltage 63 V; Mouser 667-EEU-FR1J151; not fitted
C26, C27, C28, C29, C41, C42, C43, C44: 470p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; not fitted
C30, C31, C45, C46: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 100 V; Mouser 187-CL10B104KC8NNNC; not fitted
C32, C47: 4u7; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; Voltage 16 V; Mouser 81-GRM21BR71C475KE1L
C33, C48: 470n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 25 V; Mouser 187-CL10B474KA8NNNC
J5, J7: PHOENIX CONTACT 1755752; PHOENIX_1755752; Mouser 651-1755752
J12, J13: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
J16, J17: PHOENIX_MVSTBR 2,5 4-ST-5,08; Mouser 651-1792265
MOT2, MOT3: TMC2130-LA; TMC_QFN36_0.5_5.0X6.0; Mouser 700-TMC2130LA
R31, R36, R37, R41, R43, R49, R54, R55, R59, R61: 0R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser 603-RC0603FR-100RL
R32, R33, R34, R35, R38, R44, R45, R50, R51, R52, R53, R56, R62, R63: 22R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser 603-AC0603JR-0722RL
R39, R40, R57, R58: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser 603-RC0603JR-0710KL
R42, R60, R78, R79: 0R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
R46, R47, R64, R65: 0R22; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder; Mouser 603-RL1206FR070R22L
R48, R66: 2R2; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser 603-RC0603JR-072R2L
TP3, TP4, TP5, TP6: TestPoint; TestPoint_Pad_D1.0mm

Connections of its further copies:
+3V3: C34.2, C49.2, MOT2.8 (VCC_IO), MOT3.8 (VCC_IO), R39.1, R40.1, R57.1, R58.1; also elsewhere on the board
+6V: C68.2, C69.2, MOT2.30 (VSA), MOT3.30 (VSA); also elsewhere on the board
/CPU/AIN_REF: R43.1, R61.1; also elsewhere on the board
/CPU/CLK: R34.1, R52.1; also elsewhere on the board
/CPU/DRV1_DIAGNOSTIC: MOT2.21 (DIAG1_SWP), R40.2; also elsewhere on the board
/CPU/DRV1_DIR: R45.1; also elsewhere on the board
/CPU/DRV1_EN: R38.1; also elsewhere on the board
/CPU/DRV1_STEP: R44.1; also elsewhere on the board
/CPU/DRV2_DIAGNOSTIC: MOT3.21 (DIAG1_SWP), R58.2; also elsewhere on the board
/CPU/DRV2_DIR: R63.1; also elsewhere on the board
/CPU/DRV2_EN: R56.1; also elsewhere on the board
/CPU/DRV2_STEP: R62.1; also elsewhere on the board
/CPU/MISO: R32.1, R50.1; also elsewhere on the board
/CPU/MOSI: R33.1, R51.1; also elsewhere on the board
/CPU/~DRV1_SPI_SS: R35.1; also elsewhere on the board
/CPU/~DRV2_SPI_SS: R53.1; also elsewhere on the board
GND: C22.1, C23.1, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.1, C31.1, C32.1, C33.1, C34.1, C37.1, C38.1, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.1, C46.1, C47.1, C48.1, C49.1, C68.1, C69.1, C74.1, C75.1, J12.3, J13.3, MOT2.12 (GNDP_1), MOT2.24 (GNDA), MOT2.35 (GNDP_2), MOT2.36 (TST_MODE), MOT2.37 (GND_PAD), MOT3.12 (GNDP_1), MOT3.24 (GNDA), MOT3.35 (GNDP_2), MOT3.36 (TST_MODE), MOT3.37 (GND_PAD), R31.1, R36.1, R37.1, R41.1, R42.1, R46.1, R47.1, R49.1, R54.1, R55.1, R59.1, R60.1, R64.1, R65.1; also elsewhere on the board
unnamed: C26.1, J5.1, MOT2.34 (OA1)
unnamed: C27.1, J5.2, MOT2.32 (OA2)
unnamed: C28.1, J5.3, MOT2.13 (OB1)
unnamed: C29.1, J5.4, MOT2.15 (OB2)
unnamed: C41.1, J7.1, MOT3.34 (OA1)
unnamed: C42.1, J7.2, MOT3.32 (OA2)
unnamed: C43.1, J7.3, MOT3.13 (OB1)
unnamed: C44.1, J7.4, MOT3.15 (OB2)
unnamed: J12.1, MOT2.6 (STEP_REFL), R44.2
unnamed: J12.2, R78.1
unnamed: J13.1, MOT3.6 (STEP_REFL), R62.2
unnamed: J13.2, R79.1
unnamed: C32.2, MOT2.25 (5V_OUT), R48.2
unnamed: MOT2.23 (AIN_IREF), R43.2
unnamed: C31.2, MOT2.33 (BRA), R47.2, TP4.1
unnamed: C30.2, MOT2.14 (BRB), R46.2, TP3.1
unnamed: MOT2.1 (CLK), R31.2
unnamed: C20.1, MOT2.28 (CPI)
unnamed: C20.2, MOT2.27 (CPO)
unnamed: MOT2.18 (DCEN_ENCB_CFG4), R36.2
unnamed: MOT2.19 (DCIN_ENCA_CFG5), R37.2
unnamed: MOT2.17 (DCO_ENCN), R41.2
unnamed: MOT2.20 (DIAG0_SWN), R39.2
unnamed: MOT2.7 (DIR_REFR), R45.2
unnamed: MOT2.22 (DRV_~EN_CFG6), R38.2
unnamed: MOT2.3 (SCK_CFG2), R34.2
unnamed: MOT2.4 (SDI_CFG1), R33.2
unnamed: MOT2.5 (SDO_CFG0), R32.2
unnamed: MOT2.10 (SPI_MODE), R42.2
unnamed: C33.2, MOT2.26 (VCC), R48.1
unnamed: C21.1, MOT2.29 (VCP)
unnamed: MOT2.2 (~CS_CFG3), R35.2
unnamed: C47.2, MOT3.25 (5V_OUT), R66.2
unnamed: MOT3.23 (AIN_IREF), R61.2
unnamed: C46.2, MOT3.33 (BRA), R65.2, TP6.1
unnamed: C45.2, MOT3.14 (BRB), R64.2, TP5.1
unnamed: MOT3.1 (CLK), R49.2
unnamed: C35.1, MOT3.28 (CPI)
unnamed: C35.2, MOT3.27 (CPO)
unnamed: MOT3.18 (DCEN_ENCB_CFG4), R54.2
unnamed: MOT3.19 (DCIN_ENCA_CFG5), R55.2
unnamed: MOT3.17 (DCO_ENCN), R59.2
unnamed: MOT3.20 (DIAG0_SWN), R57.2
unnamed: MOT3.7 (DIR_REFR), R63.2
unnamed: MOT3.22 (DRV_~EN_CFG6), R56.2
unnamed: MOT3.3 (SCK_CFG2), R52.2
unnamed: MOT3.4 (SDI_CFG1), R51.2
unnamed: MOT3.5 (SDO_CFG0), R50.2
unnamed: MOT3.10 (SPI_MODE), R60.2
unnamed: C48.2, MOT3.26 (VCC), R66.1
unnamed: C36.1, MOT3.29 (VCP)
unnamed: MOT3.2 (~CS_CFG3), R53.2
VEXT: C21.2, C22.2, C23.2, C24.1, C25.1, C36.2, C37.2, C38.2, C39.1, C40.1, C74.2, C75.2, MOT2.16 (VS_1), MOT2.31 (VS_2), MOT3.16 (VS_1), MOT3.31 (VS_2), R78.2, R79.2; also elsewhere on the board

Notes on the sheet:
TMC2130-CONFIGURATION
DEBUG STEP SIGNAL SERVO MOTOR OPTIONS (SG90 - SAVOX)
SPI_MODE - PIN 10 - HIGH(internal pull up) - SPI interface selected
DCEN_CFG4 - PIN 18 - LOW - no DcStep

Parts:
C50, C51, C52, C55, C58, C59, C60, C61, C63, C65, C70: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 100V; Mouser 187-CL10B104KC8NNNC
C53, C57, C67: 4u7; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; Voltage 16 V; Mouser 81-GRM21BR71C475KE1L
C54: 4u7; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Voltage 100 V; Mouser 81-GRM31CZ72A475K11L
C56: 22u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Voltage 16 V; Mouser 187-CL31A226MOCLNNC
C66: 220 pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage 50 V; Mouser 80-C0603C221J5GAUTLR
D1: 13V; D_SOD-123; Mouser 771-BZT52-C13J
F1: Polyfuse 500 mA; Fuse_1210_3225Metric_Pad1.42x2.65mm_HandSolder; Mouser 650-MICROSMD050F-2
F3: 12 A; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder; Mouser SF-1206HH1200R-2
FB1, FB2, FB4: FerriteBead; Wurth_CBF_0805; Mouser 710-742792030
J9: USB4105-GF-A; USB-TYPE-C-12P; Mouser 640-USB4105-GF-A
J10: Phoenix 1987096; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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; Mouser 651-1987096
L1: 47uH; L_Taiyo-Yuden_NR-60xx; Mouser 963-NRS6028T470MMGJ
Q1: DMPH6050SK3-13; TO-252-2; Mouser 621-DMPH6050SK3-13
Q2, Q3: BS870; SOT-23; Mouser 621-BS870-F
R7, R74, R88: 360K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser 603-RT0603FRE07360KL
R67, R68: 5.1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser 603-RC0603FR-105K1L
R69, R70, R71, R72, R83, R84: 22R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser 603-AC0603JR-0722RL
R73, R76, R86: 56.2K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser 603-RC0402FR-0756K2L
R75: 1M; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser 603-RC0603FR-071ML
R85: 18K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser 603-RC0402FR-0718KL
R89: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser 603-RC0603JR-0710KL
TP8, TP10, TP11, TP14, TP15: TestPoint_Pad_D1.0mm
U2: FT230XQ; QFN-16-1EP_4x4mm_P0.65mm_EP2.1x2.1mm; Mouser 895-FT230XQ-R
U3: USBLC6-2SC6; SOT-23-6; Mouser 511-USBLC6-2SC6
U4: LMR51610XDBVR; SOT-23-6; Mouser 595-LMR51610XDBVR
U6: TXS0102DCUR; VSSOP-8_2.3x2mm_P0.5mm; MPN TXS0102DCUR; LCSC C53434
U7: AP2127K-ADJTRG1; SOT-23-5; MPN AP2127K-ADJTRG1; LCSC C96343
U8: MCP6001-OT; SOT-23-5; Mouser 579-MCP6001T-E/OT

Connections:
+3V3: C65.1, C66.2, C67.2, C70.1, Q3.3 (D), R86.2, R89.2, TP10.1, U6.3 (VCCA), U7.5 (VOUT), U8.5 (V+); also elsewhere on the board
+6V: C56.2, FB1.2, TP11.1, U7.1 (VDD), U7.3 (EN); also elsewhere on the board
/CPU/MOD_NWAKE: Q2.2 (S), R89.1; also elsewhere on the board
/CPU/MOD_RX: R83.1; also elsewhere on the board
/CPU/MOD_TX: R84.1; also elsewhere on the board
/CPU/VEXT_SENSE: U8.1, U8.4 (-); also elsewhere on the board
GND: C50.2, C52.2, C53.1, C54.1, C55.2, C56.1, C57.1, C58.2, C59.2, C60.2, C61.2, C63.2, C65.2, C67.1, C70.2, J9.1 (GND), J9.12 (GND), J9.SH (SHIELD), J10.1, R7.1, R67.1, R68.1, R73.1, R76.1, R85.2, R88.1, TP8.1, U2.3 (GND), U2.13 (GND), U2.17 (GND), U3.2 (GND), U4.2 (GND), U6.2 (GND), U7.2 (GND), U8.2 (V-); also elsewhere on the board
unnamed: C57.2, C58.1, FB1.1, L1.2, R74.1
unnamed: C59.1, F3.2, FB4.1, R75.2
unnamed: D1.2 (A), Q1.1 (G), R88.2
unnamed: D1.1 (K), FB4.2, Q1.3 (S)
unnamed: F1.1, J9.2 (VBUS), J9.11 (VBUS)
unnamed: J9.4 (CC1), R68.2
unnamed: J9.10 (CC2), R67.2
unnamed: J9.5 (DN2), J9.7 (DN1), U3.3 (I/O2)
unnamed: J9.6 (DP1), J9.8 (DP2), U3.1 (I/O1)
unnamed: F3.1, J10.2
unnamed: Q2.1 (G), Q2.3 (D), U2.16 (~RTS)
unnamed: C52.1, C53.2, FB2.2, Q3.1 (G), U2.10 (VCC)
unnamed: Q3.2 (S), R7.2, U6.6 (OE)
unnamed: R69.2, U3.4 (I/O2)
unnamed: R70.2, U3.6 (I/O1)
unnamed: C50.1, C63.1, U2.1 (VCCIO), U2.8 (3V3OUT), U2.9 (~RESET), U6.7 (VCCB)
unnamed: R72.2, U2.2 (RXD)
unnamed: R71.2, U2.15 (TXD)
unnamed: R69.1, U2.7 (USBDM)
unnamed: R70.1, U2.6 (USBDP)
unnamed: C61.1, F1.2, FB2.1, U3.5 (VBUS)
unnamed: C51.1, U4.1 (CB)
unnamed: R73.2, R74.2, U4.3 (FB)
unnamed: C51.2, L1.1, U4.6 (SW)
unnamed: R83.2, TP14.1, U6.5 (A1)
unnamed: R84.2, TP15.1, U6.4 (A2)
unnamed: R71.1, U6.8 (B1)
unnamed: R72.1, U6.1 (B2)
unnamed: C66.1, R85.1, R86.1, U7.4 (ADJ)
unnamed: C60.1, R75.1, R76.2, U8.3 (+)
VEXT: C54.2, C55.1, Q1.2 (D), U4.4 (EN), U4.5 (VIN); also elsewhere on the board

Notes on the sheet:
DESIGN NOTE: Level shifter to prevent back feeding voltage through the IO pins when the external voltage is not present
DESIGN NOTE: V_{out} = 0.8 V * (360 + 56.2) / 56.2 = 5.92 V I_{out} = 600 mA
DESIGN NOTE: V_{out} = 0.8V * (1 + 56.2K / 18K) = 3.3V I_{out} = 300 mA
V_{in} from 6.5 V to 45 V I_{in(max)} 8 A
